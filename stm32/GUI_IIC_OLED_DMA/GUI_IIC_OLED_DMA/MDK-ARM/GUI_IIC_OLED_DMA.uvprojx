# Keil uVision project GUI_IIC_OLED_DMA.uvprojx, settings and files
target GUI_IIC_OLED_DMA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GUI_IIC_OLED_DMA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../IIC/Inc;../IIC/Interface;../IIC/Src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User/Core
    ./: startup_stm32f429xx.s
    ../Core/Src/: main.c gpio.c dma.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group IIC.H
    ../IIC/Inc/: config.h ConvertColor.h FONT_MACRO.H font5_7.h FONT8_8.H FONT24_32.H GUI_BASIC.H GUI_CONFIG.H GUI_StockC.h Loadbit.h MENU.H spline.h windows.h
  group IIC.C
    ../IIC/Src/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C loadbit.c menu.c spline.c windows.c
  group IIC.BASE
    ../IIC/Interface/: lcmBase.c lcmBase.H OLED.c OLED.h
software components: CMSIS:CORE 4.3.0
